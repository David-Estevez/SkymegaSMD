# Repository David-Estevez/SkymegaSMD

File README.md:

SkymegaSMD
==========

Arduino-based electronics board for controlling modular robots.

## KiCad design skymegaSMD.kicad_pcb

Parts:
BT1: JP_4
C1, C2, C7: 0.1uF
C3: 10uF
C4, C5: C
C6: 10uF, tantalum
C8, C9, C11, C12, C13, C14, C15, C16: 1uF
C10: 100nF
CP1, CP2: MOLEX-2
D1, D2: RED
D3, D4: BLUE
D5: GREEN
H1: HEAD3X2
I2C1: JP_4
IC1: ATMEGA328P-A; TQFP32
K1: CONN_3
P1, P2: CONN_2
R1, R2, R3, R4, R7: 1K
R5, R6: R
R8: 10K
SERIAL1: M6
SERVO_1, SERVO_2, SERVO_3, SERVO_4, SERVO_5, SERVO_6, SERVO_7, SERVO_8: JP_3
SW1: SWITCH On_Off
SW2, SW3: SW_PUSH
U1: MIC5205
X1: 16Mhz

Connections:
/A0: IC1.23 ((PCINT8/ADC0)PC0), SERVO_5.3
/A1: IC1.24 ((PCINT9/ADC1)PC1), SERVO_6.3
/A2: IC1.25 ((PCINT10/ADC2)PC2), SERVO_7.3
/A3: IC1.26 ((PCINT11/ADC3)PC3), SERVO_8.3
/A4: I2C1.2, IC1.27 ((PCINT12/SDA/ADC4)PC4), R6.2; also elsewhere on the board
/A5: I2C1.3, IC1.28 ((PCINT14/SCL/ADC5)PC5), R5.2; also elsewhere on the board
/A6: IC1.19 (ADC6), P1.1
/A7: IC1.22 (ADC7), P1.2 (PM)
/D2: IC1.32 ((PCINT18/INT0)PD2), SW2.2
/D3: IC1.1 ((PCINT19/OC2B/INT1)PD3), P2.1
/D4: IC1.2 ((PCINT20/XCK/T0)PD4), P2.2 (PM)
/D5: IC1.9 ((PCINT21/OC0B/T1)PD5), K1.1
/D6: IC1.10 ((PCINT22/OC0A/AIN0)PD6), K1.2 (PM)
/D7: IC1.11 ((PCINT23/AIN1)PD7), K1.3
/D8: IC1.12 ((PCINT0/CLKO/ICP1)PB0), SERVO_1.3
/D9: IC1.13 ((PCINT1/OC1A)PB1), SERVO_2.3
/D10: IC1.14 ((PCINT2/OC1B/~SS~)PB2), SERVO_3.3
/D11: H1.5 (MOSI), IC1.15 ((PCINT3/OC2A/MOSI)PB3), SERVO_4.3
/D12: H1.1 (MISO), IC1.16 ((PCINT4/MISO)PB4)
/D13: D5.1 (A), H1.2 (SCK), IC1.17 ((PCINT5/SCK)PB5)
/DTR: C10.1, SERIAL1.4
/RESET: C10.2, H1.3 (Reset), IC1.29 ((PCINT14/~RESET~)PC6), R8.2, SW3.2
/RX: BT1.3, IC1.30 ((PCINT16/RXD)PD0), R2.2, SERIAL1.3
/SERVO_PWR_2: C13.1, C14.1, C15.1, C16.1, CP2.1, D4.1 (A), SERVO_5.2, SERVO_6.2, SERVO_7.2, SERVO_8.2
/TX: BT1.4, IC1.31 ((PCINT17/TXD)PD1), R1.2, SERIAL1.2
/Vin: C3.1, C8.1, C9.1, C11.1, C12.1, D3.1 (A), SERVO_1.2, SERVO_2.2, SERVO_3.2, SERVO_4.2, SW1.1, U1.1 (Vin), U1.2 (EN)
GND: BT1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, CP1.2, CP2.2, H1.4 (GND), I2C1.4, IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), R3.2, R4.2, R7.2, SERIAL1.1, SERVO_1.1, SERVO_2.1, SERVO_3.1, SERVO_4.1, SERVO_5.1, SERVO_6.1, SERVO_7.1, SERVO_8.1, SW2.1, SW3.1, U1.3 (GND); also elsewhere on the board
unnamed: D2.2 (K), R2.1
unnamed: D5.2 (K), R7.1
unnamed: D1.2 (K), R1.1
unnamed: D3.2 (K), R3.1
unnamed: CP1.1, SW1.2
unnamed: D4.2 (K), R4.1
unnamed: C2.1, IC1.20 (AREF)
unnamed: C4.1, IC1.8 ((PCINT7/XTAL2/TOSC2)PB7), X1.1
unnamed: C5.1, IC1.7 ((PCINT6/XTAL1/TOSC1)PB6), X1.2
VCC: BT1.1, C1.1, C6.1, C7.1, D1.1 (A), D2.1 (A), H1.6 (VCC), I2C1.1, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), R5.1, R6.1, R8.1, U1.5 (Vout); also elsewhere on the board

Notes on the sheet:
In Circuit Serial Programming header
5V-6V
Servo Connectors x8
Microcontroller
5V LDO Regulator
Power connectors & LED indicators
Power flags
Expansion headers
Bluetooth connector
USER LED & USER Push switch
Serial Port & LED indication
I2C bus connector
Reset push switch

Board: 2 copper layers, 49.0 x 49.0 mm, 56 parts (1 on the bottom side), 37 nets.

Other parts of the board:
I2C: JP_4; CON1X4
Taladro3mm, Taladro3mm#2, Taladro3mm#3, Taladro3mm#4: 3mm; Taladro3mm

Their connections:
/A4: I2C.2; also elsewhere on the board
/A5: I2C.3; also elsewhere on the board
GND: I2C.4; also elsewhere on the board
VCC: I2C.1; also elsewhere on the board

## Commit log

2014-03-10 initial commit.
2014-03-11 Finished basic schematic for the board.
2014-03-12 Footprint assignation and board layout.
2014-03-13 All components placed, capacitors bug solved.
2014-03-14 More things routed.
2014-03-14 Only a line left.
2014-03-17 Production PCB
2014-03-17 Gerber files for seeedstudio
2014-06-24 Version presented on thesis.
2014-07-20 Some bugs solved.
2014-07-21 Edited silkscreen.

Notices in the files:
skymegaSMD.kicad_pcb:
GPLv3
